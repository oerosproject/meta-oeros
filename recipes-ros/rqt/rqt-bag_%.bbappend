# Copyright (c) 2026 Wind River Systems, Inc.
#
# Same problem as rqt-gui: the rqt_bag script lands in share/lib/rqt_bag.
inherit oeros-ament-python-lib
