# Copyright (c) 2026 Wind River Systems, Inc.
#
# rqt_gui's "rqt_gui" script is installed as share/lib/rqt_gui/rqt_gui, so
# "ros2 run rqt_gui rqt_gui" fails with "No executable found".  See the class.
inherit oeros-ament-python-lib
